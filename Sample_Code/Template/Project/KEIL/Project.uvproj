# Keil uVision project Project.uvproj, settings and files
target PERIOD_1000MS (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: PERIOD_1000MS +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: PERIOD_1000MS
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: main.c misc_config.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
target PERIOD_2000MS (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: as above
  output: PERIOD_2000MS +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: PERIOD_2000MS
  c include: as above
  link misc: REMOVEUNUSED
target PERIOD_3750MS (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: as above
  output: PERIOD_3750MS +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: PERIOD_3750MS
  c include: as above
  link misc: REMOVEUNUSED
target PERIOD_5000MS (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: as above
  output: PERIOD_5000MS +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: PERIOD_5000MS
  c include: as above
  link misc: REMOVEUNUSED
target PERIOD_10000MS (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: as above
  output: PERIOD_10000MS +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: PERIOD_10000MS
  c include: as above
  link misc: REMOVEUNUSED
target PERIOD_14000MS (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: as above
  output: PERIOD_14000MS +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: PERIOD_14000MS
  c include: as above
  link misc: REMOVEUNUSED
